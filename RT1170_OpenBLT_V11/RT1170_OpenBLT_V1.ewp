# IAR project RT1170_OpenBLT_V1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; evkmimxrt1170/driver_examples/enet/txrx_transfer/cm7; mdio; phy; utilities; xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: RT1170_OpenBLT_V1.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; UART_READ_RETRY_TIMES=1
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; evkmimxrt1170/driver_examples/enet/txrx_transfer/cm7; mdio; phy; utilities; xip; OpenBLT/Source; OpenBLT/Source/third_party/uip/uip; OpenBLT/Source/third_party/uip/apps/dhcpc; OpenBLT/i.MXRT/; OpenBLT/Boot/; OpenBLT/lib; OpenBLT/lib/uip
  ICCARM.CCOptLevel: 1
  ILINK.IlinkConfigDefines: __stack_size__=0x4000; __heap_size__=0x4000
  ILINK.IlinkIcfFile: MIMXRT1176\iar\MIMXRT1176xxxxx_cm7_flexspi_nor_openblt.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1176DVMAA_cm7; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_sdram.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_enet.c fsl_enet.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_pmu.c fsl_pmu.h
  group evkmimxrt1170
    evkmimxrt1170/: evkmimxrt1170_connect_cm4_cm7side.jlinkscript evkmimxrt1170_connect_cm7.mac
  group mdio
    mdio/: fsl_enet_mdio.c fsl_enet_mdio.h fsl_mdio.h
  group MIMXRT1176/iar
    MIMXRT1176/iar/: MIMXRT1176xxxxx_cm7_flexspi_nor.icf MIMXRT1176xxxxx_cm7_ram.icf MIMXRT1176xxxxx_cm7_sdram.icf
  group OpenBLT
    OpenBLT/Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group OpenBLT/third_party/uip
    OpenBLT/Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    OpenBLT/Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
  group phy
    phy/: fsl_phy.h fsl_phyksz8081.c fsl_phyksz8081.h
  group source
    OpenBLT/Boot/: blt_conf.h hooks.c main.c shared_params.c shared_params.h
    source/: enet_txrx_transfer.c
  group source/i.MXRT
    OpenBLT/i.MXRT/: can.c cpu.c flash.c flash.h flexspi_app.h flexspi_nor_flash_ops.c nvm.c rs232.c timer.c types.h usb.c
  group source/i.MXRT/IAR
    OpenBLT/i.MXRT/IAR/: cpu_comp.c
  group source/lib/uip
    OpenBLT/lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group startup
    startup/: startup_MIMXRT1176_cm7.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
